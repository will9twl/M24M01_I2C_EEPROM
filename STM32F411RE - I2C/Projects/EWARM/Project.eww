<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F411RE - I2C.ewp</path>
  </project>
  <batchBuild />
</workspace>
